# Keil uVision project modbusTest.uvprojx, settings and files
target ModbusSlave_AT32F423 (5060750::V5.06.7 (build 960)::.\ARMCC)
  device: AT32F423K8U7_4 ArteryTek
  pack: ArteryTek.AT32F423_DFP.1.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: modbusTest +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,AT32F423K8U7_4
  c include: inc;src;src\protocol;src\hal;src\app;src\port;Libraries\drivers\inc;Libraries\cmsis\cm4\core_support;Libraries\cmsis\cm4\device_support
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    src/: main.c
  group Protocol
    src/protocol/: modbus_rtu.c modbus_pdu.c modbus_crc.c
  group HAL
    src/hal/: hal_uart.c hal_timer.c
  group App
    src/app/: modbus_slave.c modbus_data.c
  group Port
    src/port/: port_uart_at32.c port_timer_at32.c
  group AT32_Library
    Libraries/cmsis/cm4/device_support/: system_at32f423.c
    Libraries/drivers/src/: at32f423_gpio.c at32f423_usart.c at32f423_tmr.c at32f423_crm.c
  group Startup
    Libraries/cmsis/cm4/device_support/startup/: startup_at32f423.s
